# IAR project rstc_reset_cause_sam_9x60_ek_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek_iar; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pit
    ../src/config/sam_9x60_ek_iar/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/wdt
    ../src/config/sam_9x60_ek_iar/peripheral/wdt/: plib_wdt.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/dbgu
    ../src/config/sam_9x60_ek_iar/peripheral/dbgu/: plib_dbgu_common.h plib_dbgu.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/rstc
    ../src/config/sam_9x60_ek_iar/peripheral/rstc/: plib_rstc_common.h plib_rstc.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Source Files
    ../src/: main.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: initialization.c interrupts.c cstartup.s vectortrap.s
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pit
    ../src/config/sam_9x60_ek_iar/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/wdt
    ../src/config/sam_9x60_ek_iar/peripheral/wdt/: plib_wdt.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/dbgu
    ../src/config/sam_9x60_ek_iar/peripheral/dbgu/: plib_dbgu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/rstc
    ../src/config/sam_9x60_ek_iar/peripheral/rstc/: plib_rstc.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/stdio
    ../src/config/sam_9x60_ek_iar/stdio/: iar_monitor.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_iar/: ddram.icf
